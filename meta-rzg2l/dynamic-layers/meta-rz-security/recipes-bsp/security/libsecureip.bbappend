firmware-signing.bbappend