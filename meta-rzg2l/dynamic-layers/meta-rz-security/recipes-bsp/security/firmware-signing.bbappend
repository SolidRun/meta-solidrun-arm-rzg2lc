DEV:rzg2l-sr-som = "g2l"
DEV:rzg2lc-sr-som = "g2l"
DEV:rzg2ul-sr-som = "g2l"
DEV:rzv2l-sr-som = "g2l"
