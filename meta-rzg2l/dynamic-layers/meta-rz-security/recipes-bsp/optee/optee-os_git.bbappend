PLATFORM:rzg2l-sr-som = "rz"
PLATFORM:rzg2lc-sr-som = "rz"
PLATFORM:rzg2ul-sr-som = "rz"
PLATFORM:rzv2l-sr-som = "rz"
PLATFORM_FLAVOR:rzg2l-sr-som = "g2l_smarc_2"
PLATFORM_FLAVOR:rzg2lc-sr-som = "g2lc_smarc_1"
PLATFORM_FLAVOR:rzg2ul-sr-som = "g2ul_smarc"
PLATFORM_FLAVOR:rzv2l-sr-som = "g2l_smarc_2"

# Renesas Trusted Application Sample
SRC_URI:pn-optee-ta-sample  = "file://optee-ta-sample_tsip_v2.00.tar.gz"
