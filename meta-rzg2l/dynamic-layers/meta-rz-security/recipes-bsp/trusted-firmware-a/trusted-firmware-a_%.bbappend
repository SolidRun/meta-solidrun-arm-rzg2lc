SRC_URI:append:sboot = " \
				file://g2l/0001-fix-certification-alignment.patch \
				file://g2l/0002-enable-SIMD-function.patch \
"
