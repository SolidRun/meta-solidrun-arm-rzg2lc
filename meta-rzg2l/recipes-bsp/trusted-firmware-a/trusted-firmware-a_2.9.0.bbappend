TFA_URI = "git://github.com/SolidRun/arm-trusted-firmware.git;protocol=https"
TFA_REV = "ee439acb1fe784706165697b1d1ba5fdc8af0bff"
TFA_BRANCH = "v2.9/rz-sr"
