UBOOT_URI = "git://github.com/SolidRun/u-boot.git;protocol=https"
UBOOT_BRANCH:rzg2l-family = "v2021.10/rz-vlp-4.0.0-sr"
UBOOT_REV:rzg2l-family = "0e6448ee6a327ec186a7880207102f0a461be78d"
