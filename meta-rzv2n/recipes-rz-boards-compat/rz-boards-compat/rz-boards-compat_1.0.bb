# Placeholder recipe to populate the meta-rz-boards collection.
# This is never built - it only exists so BitBake doesn't warn about
# an empty BBFILE_PATTERN for the meta-rz-boards compatibility alias.
SUMMARY = "Placeholder for meta-rz-boards collection"
LICENSE = "CLOSED"
