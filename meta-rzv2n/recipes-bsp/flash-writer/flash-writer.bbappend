FILESEXTRAPATHS:prepend:rzv2n-sr-som := "${THISDIR}/files:"

SRC_URI:rzv2n-sr-som = "file://Flash_Writer_SCIF_RZV2N_SR_SOM_8GB_LPDDR4X.mot"
