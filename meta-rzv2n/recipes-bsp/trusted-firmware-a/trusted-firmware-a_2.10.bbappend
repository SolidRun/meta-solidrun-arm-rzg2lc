TFA_URI:rzv2n-sr-som = "git://github.com/SolidRun/arm-trusted-firmware.git;protocol=https"
TFA_REV:rzv2n-sr-som = "b88cc4cc47ec5db5accfe35dfbf2afad76e067c4"
TFA_BRANCH:rzv2n-sr-som = "rzv2n_1.2.0"

SRC_URI:rzv2n-sr-som = "${TFA_URI};branch=${TFA_BRANCH}"
SRCREV:rzv2n-sr-som = "${TFA_REV}"