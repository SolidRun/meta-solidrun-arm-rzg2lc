# Enable KMS support for RZ/V2N
PACKAGECONFIG:append:rzv2n-sr-som = " kms"

# Enable bayer plugin for camera support
PACKAGECONFIG:append:rzv2n-sr-som = " bayer"
