# Skip DRP-AI U-Boot patches that only apply to Renesas EVK/dev boards
SRC_URI:remove:rzv2n-sr-som = "file://0001-add-ether-setting.patch"
