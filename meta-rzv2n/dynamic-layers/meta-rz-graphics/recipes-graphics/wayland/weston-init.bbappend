# Override weston.ini to use DRM backend for RZ/V2N with Mali GPU
FILESEXTRAPATHS:prepend:rzv2n-sr-som := "${THISDIR}/${PN}:"
