COMPATIBLE_MACHINE:append = "|rzv2n-sr-som"
