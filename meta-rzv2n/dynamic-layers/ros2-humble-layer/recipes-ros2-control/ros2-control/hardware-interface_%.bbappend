# Remove obsolete patch - the compiler options fix is already applied upstream
SRC_URI:remove = "file://do-not-set-compiler-options.patch"
