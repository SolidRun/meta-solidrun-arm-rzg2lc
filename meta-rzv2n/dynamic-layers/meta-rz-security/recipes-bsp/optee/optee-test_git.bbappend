optee-os_git.bbappend