PLATFORM:rzv2n-sr-som = "rz"
PLATFORM_FLAVOR:rzv2n-sr-som = "v2n_evk"

# Renesas Trusted Application Sample
SRC_URI:pn-optee-ta-sample  = "file://optee-ta-sample_tsip_v2.00.tar.gz"
