FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
        file://0001-Change-the-node-to-be-more-descriptive-of-the-use.patch \
"
