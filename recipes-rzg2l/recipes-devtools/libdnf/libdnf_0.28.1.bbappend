FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Fix-builds-on-GCC-11-and-newer-host-machines.patch"
